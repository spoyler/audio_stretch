# IAR project _mp3.ewp, settings and files
configuration Debug_iRAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC3131 NXP LPC3131
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __CC_ARM; SIZEOF_INT=4; SIZE_LONG=4; SIZE_LONG_LONG=8; FPM_DEFAULT
  ICCARM.CCIncludePath2: $PROJ_DIR$; app\; board\; modules\; efsl\inc\; efsl\conf\; _audio\include; libmad\; _stretch\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: _mp3.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\LPC313x_iRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_SDRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DBG_SDRAM
  ICCARM.CCIncludePath2: $PROJ_DIR$; app\; board\; modules\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: DBG_SDRAM
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkIcfFile: config\LPC313x_SDRAM.icf
configuration Debug_SPINOR_Boot_iRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: GettingStarted.srec
configuration Debug_SPINOR_Boot_SDRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DBG_SDRAM; BOOT_LEVEL_2
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: DBG_SDRAM; BOOT_LEVEL_2
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkIcfFile: config\LPC313x_Boot_level_2.icf
  group (top)
    ./: readme.txt
  group _audio
    _audio/_src/: lpc313x_adc10b_driver.c lpc313x_cgu_default.c lpc313x_cgu_driver.c lpc313x_dma_driver.c lpc313x_i2s_clock_driver.c lpc313x_i2s_driver.c lpc313x_intc_driver.c lpc313x_timer_driver.c lpc313x_wdt_driver.c lpc31xx_vmem_driver.c lpc_arm922t_cp15_driver.c
  group app
    app/: _boost_tpa6011.c _crypt.c _wd.c charger.c drv_booster.c keeper.c main.c
    _audio/i2s_audio/: lpc_io_stereo.c
  group board
    board/: cstartup.s vectors.s
  group efsl
    efsl/src/: debug.c dir.c disc.c efs.c extract.c fat.c file.c fs.c ioman.c ls.c mkfs.c partition.c plibc.c time.c ui.c
    efsl/src/interfaces/: lpc3131_mci_nand.c
  group libmad
    libmad/: bit.c decoder.c fixed.c frame.c huffman.c layer12.c layer3.c minimad.c stream.c synth_stereo.c timer.c version.c
  group MMU
    board/: arm926ej_cp15_drv.c
  group modules
    modules/: _aic23.c drv_cgu.c drv_i2c.c drv_intc.c drv_nand.c drv_spi.c drv_spinor.c keyb.c nand_file.c nand_w.c Sin_Table.c
    board/: spinor_bootloader.c
  group SDCard
    SDCard/: lpc313x_mci_driver.c
