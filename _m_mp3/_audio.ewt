<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug iRAM</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Debug xRAM</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release iRAM boot from NAND512(64M)</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release iRAM boot from NAND256(32M)</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release xRAM boot from NAND512(64M)</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release xRAM boot from NAND256(32M)</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release iRAM boot level 2 from NAND256(32M)</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release iRAM boot level 2 from NAND512(64M)</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>_bsp</name>
    <file>
      <name>$PROJ_DIR$\..\_bsp\board_nand_ids.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\_bsp\lpc32xx_adc_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\_bsp\lpc32xx_clcdc_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\_bsp\lpc32xx_clkpwr_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\_bsp\lpc32xx_dma_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\_bsp\lpc32xx_gpio_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\_bsp\lpc32xx_hstimer_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\_bsp\lpc32xx_hsuart_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\_bsp\lpc32xx_i2c_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\_bsp\lpc32xx_i2s_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\_bsp\lpc32xx_intc_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\_bsp\lpc32xx_kscan_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\_bsp\lpc32xx_mstimer_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\_bsp\lpc32xx_mstr_i2c_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\_bsp\lpc32xx_pwm_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\_bsp\lpc32xx_rtc_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\_bsp\lpc32xx_sdcard_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\_bsp\lpc32xx_slcnand_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\_bsp\lpc32xx_spi_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\_bsp\lpc32xx_ssp_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\_bsp\lpc32xx_timer_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\_bsp\lpc32xx_tsc_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\_bsp\lpc32xx_uart_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\_bsp\lpc32xx_wdt_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\_bsp\lpc3xxx_spwm_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\_bsp\phy3250_board.c</name>
    </file>
  </group>
  <group>
    <name>efsl</name>
    <group>
      <name>conf</name>
      <file>
        <name>$PROJ_DIR$\efsl\conf\config.h</name>
      </file>
    </group>
    <group>
      <name>inc</name>
      <group>
        <name>interfaces</name>
        <file>
          <name>$PROJ_DIR$\efsl\inc\interfaces\lpc3250_mmc.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\efsl\inc\debug.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\inc\dir.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\inc\disc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\inc\efs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\inc\error.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\inc\extract.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\inc\fat.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\inc\file.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\inc\fs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\inc\interface.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\inc\ioman.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\inc\ioman_v2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\inc\ls.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\inc\mkfs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\inc\partition.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\inc\plibc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\inc\time.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\inc\types.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\inc\ui.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <group>
        <name>interfaces</name>
        <file>
          <name>$PROJ_DIR$\efsl\src\interfaces\lpc3250_mmc.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\efsl\src\debug.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\src\dir.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\src\disc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\src\efs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\src\extract.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\src\fat.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\src\file.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\src\fs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\src\ioman.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\src\ls.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\src\mkfs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\src\partition.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\src\plibc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\src\time.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\efsl\src\ui.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>MMU</name>
    <file>
      <name>$PROJ_DIR$\board\arm926ej_cp15_drv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\board\lpc_arm922t_cp15_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\board\ttbl.c</name>
    </file>
  </group>
  <group>
    <name>Startup</name>
    <file>
      <name>$PROJ_DIR$\board\cstartup.s</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\_i2c.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\_i2s.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\_nand.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\_pll.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\_sdcard.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\_sdcard_spi.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\max98089_dr.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\readme.txt</name>
  </file>
  <file>
    <name>$PROJ_DIR$\sdr_sdram.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\sdram_common.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\write.c</name>
  </file>
</project>


