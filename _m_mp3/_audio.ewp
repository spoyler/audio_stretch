# IAR project _audio.ewp, settings and files
configuration Debug iRAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC3250 NXP LPC3250
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __CC_ARM; SIZEOF_INT=4; SIZE_LONG=4; SIZE_LONG_LONG=8; FPM_DEFAULT; __SOFTFP__
  ICCARM.CCIncludePath2: ; board\; ..\_bsp\include\; ..\lpc\include\; board\include; efsl\inc; efsl\conf; _stretch\; libmad\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: _mp3.bin
  ILINK.IlinkOutputFile: _audio.out
  ILINK.IlinkIcfFile: config\LPC3000_iRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug xRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
configuration Release iRAM boot from NAND512(64M) (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
configuration Release iRAM boot from NAND256(32M) (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
configuration Release xRAM boot from NAND512(64M) (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
configuration Release xRAM boot from NAND256(32M) (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
configuration Release iRAM boot level 2 from NAND256(32M) (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
configuration Release iRAM boot level 2 from NAND512(64M) (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: _audio.srec
  group (top)
    ./: _aic23.c _boost_tpa6011.c _crypt.c _i2c.c _nand_slc.c _pll.c _sdcard.c _wd.c charger.c drv_booster.c keeper.c keyb.c lpc_io_stereo.c main.c max98089_dr.c readme.txt sdr_sdram.c sdram_common.c
  group _bsp
    ../_bsp/: board_nand_ids.c lpc32xx_adc_driver.c lpc32xx_clcdc_driver.c lpc32xx_clkpwr_driver.c lpc32xx_dma_driver.c lpc32xx_gpio_driver.c lpc32xx_hstimer_driver.c lpc32xx_hsuart_driver.c lpc32xx_i2c_driver.c lpc32xx_i2s_driver.c lpc32xx_intc_driver.c lpc32xx_kscan_driver.c lpc32xx_mstimer_driver.c lpc32xx_mstr_i2c_driver.c lpc32xx_pwm_driver.c lpc32xx_rtc_driver.c lpc32xx_sdcard_driver.c lpc32xx_slcnand_driver.c lpc32xx_spi_driver.c lpc32xx_ssp_driver.c lpc32xx_timer_driver.c lpc32xx_tsc_driver.c lpc32xx_uart_driver.c lpc32xx_wdt_driver.c lpc3xxx_spwm_driver.c phy3250_board.c
  group efsl/conf
    efsl/conf/: config.h
  group efsl/inc
    efsl/inc/: debug.h dir.h disc.h efs.h error.h extract.h fat.h file.h fs.h interface.h ioman.h ioman_v2.h ls.h mkfs.h partition.h plibc.h time.h types.h ui.h
  group efsl/inc/interfaces
    efsl/inc/interfaces/: lpc3250_mmc.h
  group efsl/src
    efsl/src/: debug.c dir.c disc.c efs.c extract.c fat.c file.c fs.c ioman.c ls.c mkfs.c partition.c plibc.c time.c ui.c
  group efsl/src/interfaces
    efsl/src/interfaces/: lpc3250_mmc.c
  group libmad
    libmad/: bit.c decoder.c fixed.c frame.c huffman.c layer12.c layer3.c minimad.c stream.c synth_stereo.c timer.c version.c
  group MMU
    board/: arm926ej_cp15_drv.c lpc_arm922t_cp15_driver.c ttbl.c
  group SoundStretch/header
    _stretch/: _stretch.h AAFilter.h BPMDetect.h cpu_detect.h FIFOSampleBuffer.h FIFOSamplePipe.h FIRFilter.h InterpolateCubic.h InterpolateLinear.h InterpolateShannon.h PeakFinder.h RateTransposer.h RunParameters.h SoundTouch.h soundtouch_config.h STTypes.h TDStretch.h WavFile.h
  group SoundStretch/src
    _stretch/: _stretch.cpp AAFilter.cpp BPMDetect.cpp FIFOSampleBuffer.cpp FIRFilter.cpp InterpolateCubic.cpp InterpolateLinear.cpp InterpolateShannon.cpp mmx_optimized.cpp PeakFinder.cpp RateTransposer.cpp RunParameters.cpp SoundTouch.cpp sse_optimized.cpp TDStretch.cpp WavFile.cpp
  group Startup
    board/: cstartup.s iram_init.c
